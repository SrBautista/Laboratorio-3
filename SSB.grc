options:
  parameters:
    author: Maria_Natalia
    category: '[ModulosD1A]'
    copyright: UIS
    generate_options: hb
    id: SSB
    output_language: python
    title: Envolvente compleja SSB
  states: {}

blocks:
- name: Ac
  id: parameter
  parameters:
    label: Amplitud Portadora
    type: eng_float
    value: '1'
  states: {}
- name: K
  id: parameter
  parameters:
    label: USSB=1; LSSB = -1
    type: eng_float
    value: '1'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: Ac
    type: complex
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '257'
    win: firdes.WIN_HAMMING
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}

connections:
- [blocks_complex_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_complex_to_float_0, '1', blocks_multiply_const_vxx_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_complex_0, '1']
- [blocks_multiply_const_vxx_1, '0', pad_sink_1, '0']
- [hilbert_fc_0, '0', blocks_complex_to_float_0, '0']
- [pad_source_0, '0', hilbert_fc_0, '0']

metadata:
  file_format: 1
