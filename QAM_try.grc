options:
  parameters:
    author: uis-e3t
    generate_options: qt_gui
    id: QAM_try
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: A1
  id: variable_qtgui_range
  parameters:
    label: Amplitud señal TX1
    orient: Qt.Horizontal
    start: '0'
    step: '100e-6'
    stop: '2'
    value: '2'
  states: {}
- name: A2
  id: variable_qtgui_range
  parameters:
    label: Amplitud señal TX
    orient: Qt.Horizontal
    start: '0'
    step: '100e-6'
    stop: '1'
    value: '1'
  states: {}
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud Portadora
    orient: Qt.Horizontal
    start: '0'
    step: '1e-3'
    stop: '1'
    value: '100e-3'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia del TX
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia Portadora
    orient: Qt.Horizontal
    start: 50e6
    step: 1e6
    stop: 2.2e9
    value: 50e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: QAM_0
  id: QAM
  parameters:
    Ac: Ac
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: A2
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: A1
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: fc
    dev_args: '""'
    gain0: '0'
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [QAM_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', QAM_0, '1']
- [analog_sig_source_x_0_0, '0', QAM_0, '0']

metadata:
  file_format: 1
